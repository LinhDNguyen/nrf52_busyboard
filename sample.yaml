## sample.yaml
```yaml
sample:
    description: TBD
    name: TBD
tests:
-   test:
        build_only: true
        platform_whitelist: nrf52_vbluno52
        tags: samples
```
